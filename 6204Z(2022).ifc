Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-25T14:12:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 25 14:12:04 2022 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\{8014F713-84D4-44C8-8F39-A945F5387D58}\ifc * Database version: 5507 * Database creation date: Fri Nov 25 14:12:03 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 25 14:12:04 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 25 14:12:04 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6204Z Washbasin faucet, 24/48 V, Bluetooth, 6204Z(2022):6204Z Washbasin faucet, 24/48 V, Bluetooth:431268
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 16 mm; NominalDepth: 163 mm; NominalHeight: 205 mm; NominalWidth: 51 mm
Type - Electrical - Bluetooth: 5.x (D060577); Electrical Connection: 24-48V; Operating Voltage: 24 V; Protection Class: IP 67
Type - General - Author: BIMStone; BIMObjectName: 6204Z(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 23/11/2022
Type - Green Building Properties - EAN Number: 6414150101021; EMC Directive: 2014/30/EU , 2014/35/EU , 2011/65/EU; EN Standard: EN 15091; ETIM Class Number: EC010340 Electronic tap; LVI Number: 6110401; Noise Class: I (ISO 3822); NRF Number: 4203722; Sales Package dimensions (LxWxH): 585 x 225 x 95; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/6204Z; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/6204Z; URL WEEE: http://static.oras.com/WEEE/6204Z
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/6204Z; 3D View: https://static.oras.com/AR/6204Z; Catalog Drawing URL: http://static.oras.com/catdrw/6204Z; Dimension Drawing URL: http://static.oras.com/dimdrw/6204Z; FDV Document URL: http://www.oras.com/datasheet/6204Z/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6204Z; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/6204Z; Interactive AR View URL: https://static.oras.com/AR/6204Z; Long Marketing: Touchless Bluetooth basin faucet with a mixer valve. Electrical connection 24/48 V. Recognition range can be adjusted from the faucet. Oras Data Terminal can be used to set parameters, collect data and carry out a variety of servicing operations. (Oras No. 198081/m) 3 - 6 and 9 meters photocell cables available Adjust settings from Bluetooth app Auto Flush Recognition After flow Max Flow time; Manufacturer: Oras; Market: International;Finland;Sweden;Denmark;Poland;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/6204Z; Model: 6204Z Washbasin faucet, 24/48 V, Bluetooth; Name_en: 6204Z Washbasin faucet, 24/48 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6204Z; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6204Z; Product URL: http://static.oras.com/6204Z; Spare-Part Information URL: http://static.oras.com/sp/6204Z; Technical DataSheet URL: http://www.oras.com/datasheet/6204Z/en; Type Name: 6204Z Washbasin faucet, 24/48 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: AA; Connection Size: Ø10 mm; Electronic Parts: Infrared sensor;Power supply; Flow Rate At 300kPa With Flow Controller: 0.00388461 m3/s; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Non-return valve(s);Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 0-130 mm (0-400 mm); Pressure Loss With Flow 01ls: 170000 Pa; Spout Projection: 120 mm; Surface treatment: Chrome; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6204Z(2022); Features: Touchless;External transformer;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6204Z; Name: 6204Z Washbasin faucet, 24/48 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 50x165x205 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6204Z; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6204Z Washbasin faucet, 24/48 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.054093 m2; Volume: 0.00171623 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6204Z(2022): 6204Z Washbasin faucet, 24/48 V, Bluetooth; Family and Type: 6204Z(2022): 6204Z Washbasin faucet, 24/48 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6204Z(2022): 6204Z Washbasin faucet, 24/48 V, Bluetooth; Type Id: 6204Z(2022): 6204Z Washbasin faucet, 24/48 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
